#include "hud.h"
#include "../config.h"
#include <cstring>
#include <cstdio>

static uint8_t s_font[59][7];

static uint8_t reverse5(uint8_t v) {
    uint8_t r = 0;
    for (int i = 0; i < 5; i++) {
        if (v & (1 << i)) r |= (1 << (4 - i));
    }
    return r;
}

static void font_init(void) {
    static const uint8_t normal[59][7] = {
        {0x00,0x00,0x00,0x00,0x00,0x00,0x00},
        {0x04,0x04,0x04,0x04,0x00,0x00,0x04},
        {0x0A,0x0A,0x00,0x00,0x00,0x00,0x00},
        {0x0A,0x1F,0x0A,0x0A,0x1F,0x0A,0x00},
        {0x04,0x0F,0x14,0x0E,0x05,0x1E,0x04},
        {0x18,0x19,0x02,0x04,0x08,0x13,0x03},
        {0x0C,0x12,0x14,0x08,0x15,0x12,0x0D},
        {0x04,0x04,0x08,0x00,0x00,0x00,0x00},
        {0x02,0x04,0x08,0x08,0x08,0x04,0x02},
        {0x08,0x04,0x02,0x02,0x02,0x04,0x08},
        {0x00,0x0A,0x04,0x1F,0x04,0x0A,0x00},
        {0x00,0x04,0x04,0x1F,0x04,0x04,0x00},
        {0x00,0x00,0x00,0x00,0x00,0x04,0x08},
        {0x00,0x00,0x00,0x1F,0x00,0x00,0x00},
        {0x00,0x00,0x00,0x00,0x00,0x00,0x04},
        {0x00,0x01,0x02,0x04,0x08,0x10,0x00},
        {0x0E,0x11,0x13,0x15,0x19,0x11,0x0E},
        {0x04,0x0C,0x04,0x04,0x04,0x04,0x0E},
        {0x0E,0x11,0x01,0x02,0x04,0x08,0x1F},
        {0x1F,0x02,0x04,0x02,0x01,0x11,0x0E},
        {0x02,0x06,0x0A,0x12,0x1F,0x02,0x02},
        {0x1F,0x10,0x1E,0x01,0x01,0x11,0x0E},
        {0x06,0x08,0x10,0x1E,0x11,0x11,0x0E},
        {0x1F,0x01,0x02,0x04,0x08,0x08,0x08},
        {0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E},
        {0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C},
        {0x00,0x00,0x04,0x00,0x00,0x04,0x00},
        {0x00,0x00,0x04,0x00,0x00,0x04,0x08},
        {0x02,0x04,0x08,0x10,0x08,0x04,0x02},
        {0x00,0x00,0x1F,0x00,0x1F,0x00,0x00},
        {0x08,0x04,0x02,0x01,0x02,0x04,0x08},
        {0x0E,0x11,0x01,0x02,0x04,0x00,0x04},
        {0x0E,0x11,0x1D,0x15,0x1D,0x10,0x0E},
        {0x0E,0x11,0x11,0x1F,0x11,0x11,0x11},
        {0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E},
        {0x0E,0x11,0x10,0x10,0x10,0x11,0x0E},
        {0x1E,0x11,0x11,0x11,0x11,0x11,0x1E},
        {0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F},
        {0x1F,0x10,0x10,0x1E,0x10,0x10,0x10},
        {0x0E,0x11,0x10,0x17,0x11,0x11,0x0E},
        {0x11,0x11,0x11,0x1F,0x11,0x11,0x11},
        {0x0E,0x04,0x04,0x04,0x04,0x04,0x0E},
        {0x07,0x02,0x02,0x02,0x02,0x12,0x0C},
        {0x11,0x12,0x14,0x18,0x14,0x12,0x11},
        {0x10,0x10,0x10,0x10,0x10,0x10,0x1F},
        {0x11,0x1B,0x15,0x15,0x11,0x11,0x11},
        {0x11,0x19,0x15,0x13,0x11,0x11,0x11},
        {0x0E,0x11,0x11,0x11,0x11,0x11,0x0E},
        {0x1E,0x11,0x11,0x1E,0x10,0x10,0x10},
        {0x0E,0x11,0x11,0x11,0x15,0x12,0x0D},
        {0x1E,0x11,0x11,0x1E,0x14,0x12,0x11},
        {0x0E,0x11,0x10,0x0E,0x01,0x11,0x0E},
        {0x1F,0x04,0x04,0x04,0x04,0x04,0x04},
        {0x11,0x11,0x11,0x11,0x11,0x11,0x0E},
        {0x11,0x11,0x11,0x11,0x0A,0x0A,0x04},
        {0x11,0x11,0x11,0x15,0x15,0x1B,0x11},
        {0x11,0x11,0x0A,0x04,0x0A,0x11,0x11},
        {0x11,0x11,0x0A,0x04,0x04,0x04,0x04},
        {0x1F,0x01,0x02,0x04,0x08,0x10,0x1F},
    };
    for (int i = 0; i < 59; i++) {
        for (int row = 0; row < 7; row++) {
            s_font[i][row] = reverse5(normal[i][row]);
        }
    }
}

void hud_init(void) {
    font_init();
}

void hud_draw_char(uint16_t* fb, int x, int y, char c, uint16_t color) {
    int idx = c - 32;
    if (idx < 0 || idx >= 59) return;

    for (int row = 0; row < 7; row++) {
        uint8_t bits = s_font[idx][row];
        for (int col = 0; col < 5; col++) {
            if (bits & (1 << (4 - col))) {
                int px = x + col;
                int py = y + row;
                if (px >= 0 && px < GAME_AREA_W && py >= 0 && py < GAME_AREA_H) {
                    fb[py * DISPLAY_WIDTH + px] = color;
                }
            }
        }
    }
}

void hud_draw_string(uint16_t* fb, int x, int y, const char* str, uint16_t color) {
    int len = 0;
    for (const char* p = str; *p; p++) len++;
    int fb_x = DISPLAY_WIDTH - 1 - x;
    for (int i = len - 1; i >= 0; i--) {
        hud_draw_char(fb, fb_x, y, str[i], color);
        fb_x += 6;
    }
}

void hud_draw_rect(uint16_t* fb, int x, int y, int w, int h, uint16_t color) {
    int fb_x = DISPLAY_WIDTH - 1 - x - w + 1;
    for (int dy = 0; dy < h; dy++) {
        for (int dx = 0; dx < w; dx++) {
            int px = fb_x + dx;
            int py = y + dy;
            if (px >= 0 && px < DISPLAY_WIDTH && py >= 0 && py < GAME_AREA_H) {
                fb[py * DISPLAY_WIDTH + px] = color;
            }
        }
    }
}

void hud_draw_bar(uint16_t* fb, int x, int y, int w, int h, int value, int max_val, uint16_t fg, uint16_t bg) {
    hud_draw_rect(fb, x, y, w, h, bg);
    if (max_val > 0 && value > 0) {
        int fill_w = (value * w) / max_val;
        if (fill_w > w) fill_w = w;
        hud_draw_rect(fb, x, y, fill_w, h, fg);
    }
}

void hud_draw_crosshair(uint16_t* fb, int cx, int cy, uint16_t color) {
    int size = 8;
    int gap = 3;
    int screen_cx = DISPLAY_WIDTH - 1 - cx;

    for (int i = gap; i <= size; i++) {
        if (screen_cx - i >= 0 && screen_cx - i < DISPLAY_WIDTH && cy >= 0 && cy < GAME_AREA_H)
            fb[cy * DISPLAY_WIDTH + (screen_cx - i)] = color;
        if (screen_cx + i >= 0 && screen_cx + i < DISPLAY_WIDTH && cy >= 0 && cy < GAME_AREA_H)
            fb[cy * DISPLAY_WIDTH + (screen_cx + i)] = color;
        if (screen_cx >= 0 && screen_cx < DISPLAY_WIDTH && cy - i >= 0 && cy - i < GAME_AREA_H)
            fb[(cy - i) * DISPLAY_WIDTH + screen_cx] = color;
        if (screen_cx >= 0 && screen_cx < DISPLAY_WIDTH && cy + i >= 0 && cy + i < GAME_AREA_H)
            fb[(cy + i) * DISPLAY_WIDTH + screen_cx] = color;
    }

    for (int dy = -1; dy <= 1; dy++) {
        for (int dx = -1; dx <= 1; dx++) {
            int px = screen_cx + dx;
            int py = cy + dy;
            if (px >= 0 && px < DISPLAY_WIDTH && py >= 0 && py < GAME_AREA_H) {
                fb[py * DISPLAY_WIDTH + px] = color;
            }
        }
    }
}

void hud_draw_reload_indicator(uint16_t* fb, int x, int y, int progress, int max_progress) {
    int w = 30;
    int h = 4;
    hud_draw_rect(fb, x, y, w, h, 0x2104);
    if (max_progress > 0) {
        int fill = (progress * w) / max_progress;
        if (fill > w) fill = w;
        uint16_t color = (progress < max_progress) ? 0xF800 : 0x07E0;
        hud_draw_rect(fb, x, y, fill, h, color);
    }
}
